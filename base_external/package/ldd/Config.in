## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  LDD modules.
	  Used to understand buildroot external trees and package builds.
```
